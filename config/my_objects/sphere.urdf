Commit message: added ROLLING adjective

File: config/my_objects/sphere.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 1 links, 0 joints
Links:
- link baseLink: geometry collision sphere radius=0.15; visual mesh filename=sphere.obj scale=0.15 0.15 0.15
